# Keil uVision project USBD_Printer_and_HID_Transfer.uvprojx, settings and files
target USBD_Printer_and_HID_Transfer (6120000::V6.12::.\ARMCLANG)
  device: NUC1263SD4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: USBD_Printer_and_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC1263\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1263.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1263/Source/: system_NUC1263.c
    ../../../../Library/Device/Nuvoton/NUC1263/Source/ARM/: startup_NUC1263.S
  group User
    ../: descriptors.c micro_printer_and_hid_transfer.c main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c gpio.c
