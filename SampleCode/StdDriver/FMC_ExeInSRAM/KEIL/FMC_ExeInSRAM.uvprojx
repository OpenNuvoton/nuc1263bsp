# Keil uVision project FMC_ExeInSRAM.uvprojx, settings and files
target FMC_ExeInSRAM (6180000::V6.18::ARMCLANG)
  device: NUC1263SD4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_ExeInSRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: oTime=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC1263\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\scatter.scf
  link misc: --map  --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1263/Source/: system_NUC1263.c
    ../../../../Library/Device/Nuvoton/NUC1263/Source/ARM/: startup_NUC1263.S
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c fmc.c clk.c uart.c
