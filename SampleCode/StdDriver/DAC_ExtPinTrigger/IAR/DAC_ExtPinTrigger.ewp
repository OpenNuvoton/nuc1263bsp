# IAR project DAC_ExtPinTrigger.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1263AE series Nuvoton NUC1263AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1263\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DAC_ExtPinTrigger.bin
  ILINK.IlinkOutputFile: DAC_ExtPinTrigger.out
  ILINK.IlinkIcfFile: DAC_ExtPinTrigger.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1263/Source/IAR/: startup_NUC1263.s
    ../../../../Library/Device/Nuvoton/NUC1263/Source/: system_NUC1263.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dac.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
