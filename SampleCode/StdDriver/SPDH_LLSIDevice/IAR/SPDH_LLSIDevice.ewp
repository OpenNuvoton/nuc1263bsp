# IAR project SPDH_LLSIDevice.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC126AE series Nuvoton NUC126AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe550, Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1263\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\SpdhLib\Include; ..\..\..\..\SampleCode\StdDriver\SPDH_LLSIDevice\LLSI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPDH_LLSIDevice.bin
  ILINK.IlinkOutputFile: SPDH_LLSIDevice.out
  ILINK.IlinkIcfFile: SPDH_LLSIDevice.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1263/Source/IAR/: startup_NUC1263.s
    ../../../../Library/Device/Nuvoton/NUC1263/Source/: system_NUC1263.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c fmc.c gpio.c i3cs.c llsi.c pdma.c retarget.c spdh.c sys.c timer.c uart.c
  group LLSI
    ../LLSI/: Flash.c HDIV.c LED_Control.c
  group User
    ../: LocalDevFw.c LocalDevReg.c main.c
