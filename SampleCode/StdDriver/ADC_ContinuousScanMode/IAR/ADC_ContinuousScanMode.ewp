# IAR project ADC_ContinuousScanMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1263AE series Nuvoton NUC1263AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC1263\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_ContinuousScanMode.bin
  ILINK.IlinkOutputFile: ADC_ContinuousScanMode.out
  ILINK.IlinkIcfFile: ADC_ContinuousScanMode.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1263/Source/IAR/: startup_NUC1263.s
    ../../../../Library/Device/Nuvoton/NUC1263/Source/: system_NUC1263.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
