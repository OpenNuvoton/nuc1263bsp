# Keil uVision project DAC_PDMA_TimerTrigger.uvprojx, settings and files
target DAC_PDMA_TimerTrigger (6120000::V6.12::.\ARMCLANG)
  device: NUC1263SD4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: DAC_PDMA_TimerTrigger
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC1263\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_NUC1263.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1263/Source/: system_NUC1263.c
    ../../../../Library/Device/Nuvoton/NUC1263/Source/ARM/: startup_NUC1263.S
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c dac.c gpio.c pdma.c timer.c
